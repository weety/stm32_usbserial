# Keil uVision project project.uvproj, settings and files
target stm32f103c (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f103c
  AfterMake: fromelf --bin !L --output stm32f103c.bin
  c flags: Optim=3
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .;..\components\CMSIS\Include;..\components\drivers\include;..\components\drivers\usb\usbdevice;..\include;..\libcpu\arm\common;..\libcpu\arm\cortex-m3;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;Libraries\STM32F10x_StdPeriph_Driver\inc;Libraries\STM32_USB-FS-Device_Driver\inc;applications;drivers;drivers\usb
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Applications
    applications/: application.c startup.c vcom_proc.c
  group Drivers
    drivers/: board.c stm32f10x_it.c usart.c stm32_i2c.c
    drivers/usb/: hw_config.c usb_pwr.c stm32f10x_dcd.c
  group STM32_StdPeriph
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_pwr.c stm32f10x_bkp.c stm32f10x_i2c.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_dma.c misc.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    Libraries/STM32_USB-FS-Device_Driver/src/: usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Kernel
    ../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    ../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../components/drivers/serial/: serial.c
    ../components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c
    ../components/drivers/usb/usbdevice/core/: core.c usbdevice.c
    ../components/drivers/usb/usbdevice/class/: cdc_vcom.c
